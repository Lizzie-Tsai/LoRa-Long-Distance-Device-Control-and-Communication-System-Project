# Keil uVision project Project.uvproj, settings and files
target Project (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Project +hex
  AfterMake: C:\Keil\ARM\ARMCC\bin\fromelf.exe --bin -o ./Project.bin ./Output/Project.axf
  c flags: OneElfS=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD ,PLATFORM=SX12xxEiger
  c include: ..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\CMSIS\CM3\CoreSupport;..\User;..\Libraries\STM32_USB-FS-Device_Driver\inc;..\User\USB\inc;..\User\SX1278\platform;..\User\SX1278\radio;..\User\SX1278\platform\sx12xxEiger
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group CMSIS
    ../User/: system_stm32f10x.c
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USB-FS-Device_Driver
    ../Libraries/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group USB-User
    ../User/USB/: hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
  group User Source
    ../User/: main.c stm32f10x_it.c
  group BSP
    ../User/: delay.c ledpwm.c usart.c usb_io.c adc.c bsp.c smbus.c i2c.c
  group SX1278
    ../User/SX1278/platform/sx12xxEiger/: fifo.c spi.c sx12xxEiger.c sx1232-Hal.c sx1272-Hal.c sx1276-Hal.c
  group radio
    ../User/SX1278/radio/: radio.c sx1232.c sx1232-Misc.c sx1272.c sx1272-Fsk.c sx1272-FskMisc.c sx1272-LoRa.c sx1272-LoRaMisc.c sx1276.c sx1276-Fsk.c sx1276-FskMisc.c sx1276-LoRa.c sx1276-LoRaMisc.c
